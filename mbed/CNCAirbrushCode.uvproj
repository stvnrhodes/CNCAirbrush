# Keil uVision project CNCAirbrushCode.uvproj, settings and files
target mbed NXP LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: CNCAirbrushCode
  AfterMake: fromelf --bin -o build\CNCAirbrushCode_LPC1768.bin build\CNCAirbrushCode.axf
  c flags: Optim=1
  c define: TARGET_LPC1768,  TARGET_M3,  TARGET_NXP,  TARGET_LPC176X,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M3,  ARM_MATH_CM3,
  c misc: --gnu
  c include: .;  Servo;  mbed;  mbed/LPC1768;  mbed/LPC1768/ARM;  StepperMotors;  CNCAirbrush;
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed/LPC1768/ARM/LPC1768.sct
  link misc: mbed/LPC1768/ARM/sys.o
            
              mbed/LPC1768/ARM/cmsis_nvic.o
            
              mbed/LPC1768/ARM/system_LPC17xx.o
            
              mbed/LPC1768/ARM/core_cm3.o
            
              mbed/LPC1768/ARM/startup_LPC17xx.o
            
              mbed/LPC1768/ARM/capi.ar
            
              mbed/LPC1768/ARM/mbed.ar
  group src
    ./: main.cpp
    Servo/: Servo.cpp
    StepperMotors/: LinearMotion.cpp Stepper.cpp Bitmap.cpp
    CNCAirbrush/: Wifly.cpp
